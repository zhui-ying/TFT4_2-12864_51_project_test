# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC90C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c TFT.c ch_enlib.c SD.c toutch.c uc1705.c
